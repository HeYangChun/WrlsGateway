# IAR project BoxControler.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207C8 STM8S207C8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x600
  General.GenHeapSize: 0x600
  ICCSTM8.CCIncludePath2: FWLib\inc; user; $PROJ_DIR$
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: BoxControler.hex
  ILINK.IlinkOutputFile: BoxControler.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    user/: FifoFilter.c IR.c
  group FWLib
    FWLib/src/: stm8s_adc2.c stm8s_awu.c stm8s_beep.c stm8s_can.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_uart1.c stm8s_uart3.c stm8s_wwdg.c
  group user
    user/: APP.c AT24C32A.c buffer.c COMM.c Delay.c GLOBAL.c gpio.C init.c initTask.c main.c sTimeout.c stm8s_conf.h stm8s_it.c task.c uart.c wifi.c
